# IAR project COM.MXCHIP.MicoKit3288.ewp, settings and files
configuration MiCOKit-3165 (ARM)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\Demos\COM.MXCHIP.MicoKit3288; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Library\support; ..\..\..\..\External; ..\..\..\..\Board\MiCOKit-3165; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\include\EasyCloud
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: COM.MXCHIP.MicoKit3288.bin
  ILINK.IlinkOutputFile: COM.MXCHIP.SPP.out
  ILINK.IlinkIcfFile: Y:\Develop\mxchipWNet Pro Demo@EMW316x\Board\MiCOKit-3165\micoLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MiCOKit-3288 (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\Demos\COM.MXCHIP.MicoKit3288; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Library\support; ..\..\..\..\External; ..\..\..\..\Board\MiCOKit-3288; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\include\EasyCloud; ..\..\..\..\Demos\COM.MXCHIP.MicoKit3288\AppFramework; ..\..\..\..\Demos\COM.MXCHIP.MicoKit3288\user
  ICCARM.CCOptLevel: 1
  ILINK.IlinkOutputFile: COM.MXCHIP.MicoKit3288.out
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MiCOKit-3288\micoLinkerForIAR.icf
  group Application/AppFramework
    ../../../../Demos/COM.MXCHIP.MicoKit3288/AppFramework/: fogCloud.c fogCloud.h MICOAppDefine.h MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c MicoDefaults.h MicoFogCloud.c MicoFogCloud.h MicoFogCloudConfigServer.c MicoFogCloudDef.h msg_dispatch.c msg_dispatch.h properties.c properties.h
  group Application/User
    ../../../../Demos/COM.MXCHIP.MicoKit3288/user/: properties_user.c properties_user.h user_config.h user_main.c user_main.h user_uart.c user_uart.h
  group Board/MiCOKit-3165
    ../../../../Board/MiCOKit-3165/: platform.c platform.h platform_common_config.h platform_spi_flash.c
  group Board/MiCOKit-3288
    ../../../../Board/MiCOKit-3288/: platform.c platform.h platform_common_config.h platform_spi_flash.c
  group External/Curve25519
    ../../../../External/Curve25519/: curve25519-donna.c
  group External/FatFs/Core
    ../../../../External/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group External/FatFs/Drivers
    ../../../../External/FatFs/src/drivers/: usbh_diskio.c
  group External/FatFs/Options
    ../../../../External/FatFs/src/option/: syscall.c unicode.c
  group External/GladmanAES
    ../../../../External/GladmanAES/: aes_modes.c aescrypt.c aeskey.c aestab.c gf128mul.c
  group External/JSON-C
    ../../../../External/JSON-C/: arraylist.c debug.c json.h json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group External/SHAUtils
    ../../../../External/SHAUtils/: hkdf.c hmac.c sha1.c sha224-256.c sha384-512.c usha.c
  group include
    ../../../../include/: MICO.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MicoSRPServer.h MicoWlan.h
  group include/MicoDriver
    ../../../../include/MicoDrivers/: MICODriverAdc.h MICODriverGpio.h MICODriverI2c.h MICODriverMFiAuth.h MICODriverPwm.h MICODriverRng.h MICODriverRtc.h MICODriverSpi.h MICODriverUART.h MICODriverWdg.h
  group Library
    ../../../../Library/: MICOConfig.c mxchipWNet_cm4f_8801.a mxchipWNet_cm4f_sdio.a mxchipWNet_cm4f_spi.a
    ../../../../Library/EasyCloud/: MicoEasyCloudService_debug.a MicoEasyCloudService_release.a
  group MICO
    ../../../../MICO/: MICOCli.c MICOConfigMenu.c MICOConfigServer.c MICODefine.h MICOEntrance.c MICOMfgtest.c MICONotificationCenter.c MICONTPClient.c MICOParaStorage.c MICOSystemMonitor.c
  group MICO/AirKiss
    ../../../../MICO/Airkiss/: Airkiss.c Airkiss_CM3_Debug.a Airkiss_CM3_Release.a
  group MICO/EasyLink
    ../../../../MICO/EasyLink/: EasyLink.c
    ../../../../MICO/SoftAP/: EasyLinkSoftAP.c
  group MICO/WAC
    ../../../../MICO/WAC/: MFi_WAC_CM3_Debug.a MFi_WAC_CM3_Release.a
  group MICO/WPS
    ../../../../MICO/WPS/: WPS.c
  group Platform/Cortex-M4
    ../../../../Platform/Cortex-M4/: crt0_EWARM.c hardfault.c
  group Platform/Drivers/MFiAuth
    ../../../../Platform/Drivers/MicoDriverMFiAuth/: MicoDriverMFiAuth.a
  group Platform/Drivers/SPI Flash
    ../../../../Platform/Drivers/spi_flash/: spi_flash.c
  group Platform/EWARM
    ../../../../Platform/EWARM/: Retarget.c
  group Platform/STM32F4xx/EMW1062
    ../../../../Platform/MCU/STM32F4xx/EMW1062_Driver/: read_wifi_firmware.c wlan_platform.c
  group Platform/STM32F4xx/EMW1062/SDIO
    ../../../../Platform/MCU/STM32F4xx/EMW1062_Driver/SDIO/: wlan_bus.c
  group Platform/STM32F4xx/EMW1062/SPI
    ../../../../Platform/MCU/STM32F4xx/EMW1062_Driver/SPI/: wwd_bus.c
  group Platform/STM32F4xx/EMW1088
    ../../../../Platform/MCU/STM32F4xx/EMW1088_Driver/: read_wifi_firmware.c wlan_bus.c wlan_platform.c
  group Platform/STM32F4xx/EWARM
    ../../../../Platform/MCU/STM32F4xx/EWARM/: startup_stm32f411xe_IAR.s
  group Platform/STM32F4xx/Peripherals
    ../../../../Platform/MCU/STM32F4xx/peripherals/: gpio_irq.c MicoDriverAdc.c MicoDriverFlash.c MicoDriverGpio.c MicoDriverI2c.c MicoDriverPwm.c MicoDriverRng.c MicoDriverRtc.c MicoDriverSpi.c MicoDriverUart.c MicoDriverWdg.c rtc.c stm32f4xx_platform.c
  group Platform/STM32F4xx/Peripherals/Libraries
    ../../../../Platform/MCU/STM32F4xx/peripherals/Libraries/: system_stm32f4xx.c
  group Platform/STM32F4xx/Peripherals/Libraries/STM32F4xx_StdPeriph_Driver
    ../../../../Platform/MCU/STM32F4xx/peripherals/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Support
    ../../../../Library/support/: AESUtils.c HTTPUtils.c MDNSUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
