# IAR project COM.EASYCLOUD.TEST.ewp, settings and files
configuration EMW3162 (ARM)
  General.OGChipSelectEditMenu: STM32F205ZG ST STM32F205ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\Platform; ..\..\..\Library\support; ..\..\..\Demos\COM.EASYCLOUD.TEST; ..\..\..\MICO; ..\..\..\Platform\EMW3162; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\include; ..\..\..\External; ..\..\..\Platform\include; ..\..\..\Platform\Common\Cortex-M3; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv; ..\..\..\Platform\Common\Drivers\spi_flash; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_HAL_Driver\Inc; ..\..\..\Library\EasyCloud; ..\..\..\Library\EasyCloud\EasyCloudMQTTClient; ..\..\..\Library\EasyCloud\EasyCloudMQTTClient\MQTTPacket\src; ..\..\..\Library\EasyCloud\EasyCloudMQTTClient\MQTTClient-C\src; ..\..\..\Library\EasyCloud\EasyCloudMQTTClient\MQTTClient-C\src\MICO; ..\..\..\Demos\COM.EASYCLOUD.TEST\MVDTest
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: COM.EASYCLOUD.TEST.bin
  ILINK.IlinkOutputFile: COM.EASYCLOUD.TEST.out
  ILINK.IlinkIcfFile: ..\..\..\Platform\EMW3162\micoLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MICO_EVB_1 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\Platform; ..\..\..\Library\support; ..\..\..\Demos\COM.EASYCLOUD.TEST; ..\..\..\MICO; ..\..\..\Platform\MICO_EVB_1; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\include; ..\..\..\External; ..\..\..\Platform\include; ..\..\..\Platform\Common\Cortex-M3; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv; ..\..\..\Platform\Common\Drivers\spi_flash; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_HAL_Driver\Inc; ..\..\..\External\FatFs\src\drivers; ..\..\..\External\FatFs\src; ..\..\..\Platform\Common\Drivers\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\..\Platform\Common\Drivers\STM32_USB_Host_Library\Core\Inc
  ILINK.IlinkIcfFile: ..\..\..\Platform\MICO_EVB_1\micoLinkerForIAR.icf
configuration Nucleo_411RE (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  ICCARM.CCIncludePath2: ..\..\..\Platform; ..\..\..\Library\support; ..\..\..\Demos\COM.EASYCLOUD.TEST; ..\..\..\MICO; ..\..\..\Platform\Nucleo_411RE; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\include; ..\..\..\External; ..\..\..\Platform\include; ..\..\..\Platform\Common\Cortex-M4; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv; ..\..\..\Platform\Common\Drivers\spi_flash
  ILINK.IlinkIcfFile: ..\..\..\Platform\Nucleo_411RE\micoLinkerForIAR.icf
configuration EMW3165 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  ICCARM.CCIncludePath2: ..\..\..\Platform; ..\..\..\Library\support; ..\..\..\Demos\COM.EASYCLOUD.TEST; ..\..\..\MICO; ..\..\..\Platform\EMW3165; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\include; ..\..\..\External; ..\..\..\Platform\include; ..\..\..\Platform\Common\Cortex-M4; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv; ..\..\..\Platform\Common\Drivers\spi_flash; ..\..\..\include\EasyCloud
  ILINK.IlinkIcfFile: ..\..\..\Platform\EMW3165\micoLinkerForIAR.icf
  group Application
    ../../../Demos/COM.EASYCLOUD.TEST/: MICOAppDefine.h MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c MicoDefaults.h MicoVirtualDevice.c MVDCloudInterfaces.c MVDDeviceInterfaces.c
  group Application/MVDTest
    ../../../Demos/COM.EASYCLOUD.TEST/MVDTest/: MVDCloudTest.c MVDCloudTest.h
  group External/Curve25519
    ../../../External/Curve25519/: curve25519-donna.c
  group External/FatFs/Core
    ../../../External/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group External/FatFs/Drivers
    ../../../External/FatFs/src/drivers/: usbh_diskio.c
  group External/FatFs/Options
    ../../../External/FatFs/src/option/: syscall.c unicode.c
  group External/GladmanAES
    ../../../External/GladmanAES/: aes_modes.c aescrypt.c aeskey.c aestab.c gf128mul.c
  group External/JSON-C
    ../../../External/JSON-C/: arraylist.c debug.c json.h json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group include
    ../../../include/: MICO.h MicoAES.h MicoAlgorithm.h MICOPlatform.h MICORTOS.h MicoSocket.h MicoSRPServer.h MicoWlan.h
  group include/MicoDriver
    ../../../include/MicoDrivers/: MICODriverAdc.h MICODriverGpio.h MICODriverI2c.h MICODriverMFiAuth.h MICODriverPwm.h MICODriverRng.h MICODriverRtc.h MICODriverSpi.h MICODriverUART.h MICODriverWdg.h
  group Library
    ../../../Library/: MICOConfig.c mxchipWNet_cm3_sdio.a mxchipWNet_cm3_spi.a mxchipWNet_cm4f_sdio.a mxchipWNet_cm4f_spi.a
    ../../../Library/EasyCloud/: MicoEasyCloudService_20150209_v0.3.1_debug.a MicoEasyCloudService_20150209_v0.3.1_release.a
  group Library/EasyCloud
    ../../../Library/EasyCloud/: EasyCloudService.c EasyCloudService.h EasyCloudServiceDef.h EasyCloudServiceVersion.c EasyCloudUtils.c EasyCloudUtils.h
  group Library/EasyCloud/EasyCloudMQTTClient
    ../../../Library/EasyCloud/EasyCloudMQTTClient/: EasyCloudMQTTClient.c EasyCloudMQTTClient.h
  group Library/EasyCloud/EasyCloudMQTTClient/MQTTClient-C
    ../../../Library/EasyCloud/EasyCloudMQTTClient/MQTTClient-C/src/: MQTTClient.c MQTTClient.h
  group Library/EasyCloud/EasyCloudMQTTClient/MQTTClient-C/MICO
    ../../../Library/EasyCloud/EasyCloudMQTTClient/MQTTClient-C/src/MICO/: MQTTMICO.c MQTTMICO.h
  group Library/EasyCloud/EasyCloudMQTTClient/MQTTPacket
    ../../../Library/EasyCloud/EasyCloudMQTTClient/MQTTPacket/src/: MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
  group MICO
    ../../../MICO/SoftAP/: EasyLinkSoftAP.c
    ../../../MICO/: MICOConfigMenu.c MICOConfigServer.c MICODefine.h MICOEntrance.c MICOMfgtest.c MICONotificationCenter.c MICONTPClient.c MICOParaStorage.c MICOSystemMonitor.c
  group MICO/AIRKISS
    ../../../MICO/Airkiss/: Airkiss.c Airkiss.h
  group MICO/Easylink
    ../../../MICO/EasyLink/: EasyLink.c EasyLink.h
  group Platform/common/Cortex-M3
    ../../../Platform/Common/Cortex-M3/: crt0_IAR.c hardfault.c
  group Platform/common/Cortex-M3/STM32F2xx
    ../../../Platform/Common/Cortex-M3/STM32F2xx/: gpio_irq.c gpio_irq.h MicoDriverAdc.c MicoDriverFlash.c MicoDriverGpio.c MicoDriverI2c.c MicoDriverPwm.c MicoDriverRng.c MicoDriverRtc.c MicoDriverSpi.c MicoDriverUart.c MicoDriverWdg.c rtc.c stm32f2xx_platform.c usbh_conf.c
  group Platform/common/Cortex-M3/STM32F2xx/EMW1062_Driver
    ../../../Platform/Common/Cortex-M3/STM32F2xx/EMW1062_Driver/: read_wifi_firmware.c wlan_platform.c
  group Platform/common/Cortex-M3/STM32F2xx/EMW1062_Driver/SDIO
    ../../../Platform/Common/Cortex-M3/STM32F2xx/EMW1062_Driver/SDIO/: wlan_bus.c
  group Platform/common/Cortex-M3/STM32F2xx/EMW1062_Driver/SPI
    ../../../Platform/Common/Cortex-M3/STM32F2xx/EMW1062_Driver/SPI/: wwd_bus.c
  group Platform/common/Cortex-M3/STM32F2xx/STM32F2xx_Drv
    ../../../Platform/Common/Cortex-M3/STM32F2xx/STM32F2xx_Drv/: startup_stm32f2xx_IAR.s stm32f2xx.h stm32f2xx_conf.h system_stm32f2xx.c
  group Platform/common/Cortex-M3/STM32F2xx/STM32F2xx_Drv/STM32F2xx_HAL_Driver
    ../../../Platform/Common/Cortex-M3/STM32F2xx/STM32F2xx_Drv/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_hcd.c stm32f2xx_ll_usb.c
  group Platform/common/Cortex-M3/STM32F2xx/STM32F2xx_Drv/STM32F2xx_StdPeriph_Driver
    ../../../Platform/Common/Cortex-M3/STM32F2xx/STM32F2xx_Drv/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group Platform/common/Cortex-M4
    ../../../Platform/Common/Cortex-M4/: crt0_IAR.c hardfault.c
  group Platform/common/Cortex-M4/STM32F4xx
    ../../../Platform/Common/Cortex-M4/STM32F4xx/: gpio_irq.c MicoDriverAdc.c MicoDriverFlash.c MicoDriverGpio.c MicoDriverI2c.c MicoDriverPwm.c MicoDriverRng.c MicoDriverRtc.c MicoDriverSpi.c MicoDriverUart.c MicoDriverWdg.c rtc.c stm32f4xx_platform.c
  group Platform/common/Cortex-M4/STM32F4xx/EMW1062_Driver
    ../../../Platform/Common/Cortex-M4/STM32F4xx/EMW1062_Driver/: read_wifi_firmware.c wlan_platform.c
  group Platform/common/Cortex-M4/STM32F4xx/EMW1062_Driver/SDIO
    ../../../Platform/Common/Cortex-M4/STM32F4xx/EMW1062_Driver/SDIO/: wlan_bus.c
  group Platform/common/Cortex-M4/STM32F4xx/EMW1062_Driver/SPI
    ../../../Platform/Common/Cortex-M4/STM32F4xx/EMW1062_Driver/SPI/: wwd_bus.c
  group Platform/common/Cortex-M4/STM32F4xx/STM32F4xx_Drv
    ../../../Platform/Common/Cortex-M4/STM32F4xx/STM32F4xx_Drv/: startup_stm32f411xe_IAR.s stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.c
  group Platform/common/Cortex-M4/STM32F4xx/STM32F4xx_Drv/STM32F4xx_StdPeriph_Driver
    ../../../Platform/Common/Cortex-M4/STM32F4xx/STM32F4xx_Drv/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Platform/common/Drivers
    ../../../Platform/Common/Drivers/: MicoDriverMFiAuth.a
  group Platform/common/Drivers/spi_flash
    ../../../Platform/Common/Drivers/spi_flash/: EMW3165.c MICO_EVB_1.c Nucleo_411RE.c spi_flash.c
  group Platform/common/Drivers/STM32_USBH_Library/Class/MSC
    ../../../Platform/Common/Drivers/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Platform/common/Drivers/STM32_USBH_Library/Core
    ../../../Platform/Common/Drivers/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Platform/common/IAR
    ../../../Platform/Common/IAR/: stdio_IAR.c
  group Platform/EMW3162
    ../../../Platform/EMW3162/: platform.c platform.h platform_common_config.h
  group Platform/EMW3165
    ../../../Platform/EMW3165/: platform.c platform.h platform_common_config.h
  group Platform/MICO_EVB_1
    ../../../Platform/MICO_EVB_1/: platform.c platform.h platform_common_config.h
  group Platform/Nucleo_411RE
    ../../../Platform/Nucleo_411RE/: platform.c platform.h platform_common_config.h
  group Support
    ../../../Library/support/: AESUtils.c HTTPUtils.c MDNSUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
