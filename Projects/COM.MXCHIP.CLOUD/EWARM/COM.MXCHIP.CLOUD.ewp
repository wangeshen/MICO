# IAR project COM.MXCHIP.CLOUD.ewp, settings and files
configuration EMW3162 (ARM)
  General.OGChipSelectEditMenu: STM32F205ZG ST STM32F205ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\Platform; ..\..\..\Library\support; ..\..\..\Demos\COM.MXCHIP.CLOUD; ..\..\..\MICO; ..\..\..\Platform\EMW3162; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\include; ..\..\..\External; ..\..\..\Platform\include; ..\..\..\Platform\Common\Cortex-M3; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv; ..\..\..\Platform\Common\Drivers\spi_flash; ..\..\..\Library\MicoCloudService; ..\..\..\Library\MicoCloudService\MicoMQTTClient; ..\..\..\Library\MicoCloudService\MicoMQTTClient\MQTTClient-C\src; ..\..\..\Library\MicoCloudService\MicoMQTTClient\MQTTClient-C\src\MICO; ..\..\..\Library\MicoCloudService\MicoMQTTClient\MQTTPacket\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: COM.MXCHIP.CLOUD.bin
  ILINK.IlinkOutputFile: COM.MXCHIP.CLOUD.out
  ILINK.IlinkIcfFile: ..\..\..\Platform\EMW3162\micoLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MICO_EVB_1 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\Platform; ..\..\..\Library\support; ..\..\..\Demos\COM.MXCHIP.CLOUD; ..\..\..\MICO; ..\..\..\Platform\MICO_EVB_1; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\include; ..\..\..\External; ..\..\..\Platform\include; ..\..\..\Platform\Common\Cortex-M3; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv; ..\..\..\Platform\Common\Drivers\spi_flash
  ILINK.IlinkIcfFile: ..\..\..\Platform\MICO_EVB_1\micoLinkerForIAR.icf
configuration Nucleo_411RE (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\Platform; ..\..\..\Library\support; ..\..\..\Demos\COM.MXCHIP.CLOUD; ..\..\..\MICO; ..\..\..\Platform\Nucleo_411RE; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\include; ..\..\..\External; ..\..\..\Platform\include; ..\..\..\Platform\Common\Cortex-M4; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv; ..\..\..\Platform\Common\Drivers\spi_flash
  ILINK.IlinkIcfFile: ..\..\..\Platform\Nucleo_411RE\micoLinkerForIAR.icf
  group Application
    ../../../Demos/COM.MXCHIP.CLOUD/: MicoDefaults.h
  group External/JSON-C
    ../../../External/JSON-C/: arraylist.c debug.c json.h json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group include
    ../../../include/: MICO.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MicoWlan.h
  group Library/MicoCloudService
    ../../../Library/MicoCloudService/: MicoCloudService.c MicoCloudService.h MicoCloudServiceDef.h MicoCloudServiceVersion.c
  group Library/MicoCloudService/MicoMQTTClient
    ../../../Library/MicoCloudService/MicoMQTTClient/: MicoMQTTClient.c MicoMQTTClient.h
  group Library/MicoCloudService/MicoMQTTClient/MQTTClient-C/src
    ../../../Library/MicoCloudService/MicoMQTTClient/MQTTClient-C/src/: MQTTClient.c MQTTClient.h
  group Library/MicoCloudService/MicoMQTTClient/MQTTClient-C/src/MICO
    ../../../Library/MicoCloudService/MicoMQTTClient/MQTTClient-C/src/MICO/: MQTTMICO.c MQTTMICO.h
  group Library/MicoCloudService/MicoMQTTClient/MQTTPacket/src
    ../../../Library/MicoCloudService/MicoMQTTClient/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group MICO
    ../../../MICO/: MICODefine.h MICONotificationCenter.c
  group Support
    ../../../Library/support/: HTTPUtils.c SocketUtils.c StringUtils.c
