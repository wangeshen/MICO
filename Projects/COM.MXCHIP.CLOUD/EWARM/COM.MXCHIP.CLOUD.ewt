<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>EMW3162</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>MICO_EVB_1</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Nucleo_411RE</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.CLOUD\MicoDefaults.h</name>
    </file>
  </group>
  <group>
    <name>External</name>
    <group>
      <name>JSON-C</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\arraylist.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\debug.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\json.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\json_object.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\json_tokener.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\json_util.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\linkhash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\printbuf.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>include</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\include\MICO.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\include\MicoAlgorithm.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\include\MicoPlatform.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\include\MICORTOS.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\include\MicoSocket.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\include\MicoWlan.h</name>
    </file>
  </group>
  <group>
    <name>Library</name>
    <group>
      <name>MicoCloudService</name>
      <group>
        <name>MicoMQTTClient</name>
        <group>
          <name>MQTTClient-C</name>
          <group>
            <name>src</name>
            <group>
              <name>MICO</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\Library\MicoCloudService\MicoMQTTClient\MQTTClient-C\src\MICO\MQTTMICO.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Library\MicoCloudService\MicoMQTTClient\MQTTClient-C\src\MICO\MQTTMICO.h</name>
              </file>
            </group>
            <file>
              <name>$PROJ_DIR$\..\..\..\Library\MicoCloudService\MicoMQTTClient\MQTTClient-C\src\MQTTClient.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\Library\MicoCloudService\MicoMQTTClient\MQTTClient-C\src\MQTTClient.h</name>
            </file>
          </group>
        </group>
        <group>
          <name>MQTTPacket</name>
          <group>
            <name>src</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\Library\MicoCloudService\MicoMQTTClient\MQTTPacket\src\MQTTConnectClient.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\Library\MicoCloudService\MicoMQTTClient\MQTTPacket\src\MQTTConnectServer.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\Library\MicoCloudService\MicoMQTTClient\MQTTPacket\src\MQTTDeserializePublish.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\Library\MicoCloudService\MicoMQTTClient\MQTTPacket\src\MQTTFormat.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\Library\MicoCloudService\MicoMQTTClient\MQTTPacket\src\MQTTPacket.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\Library\MicoCloudService\MicoMQTTClient\MQTTPacket\src\MQTTSerializePublish.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\Library\MicoCloudService\MicoMQTTClient\MQTTPacket\src\MQTTSubscribeClient.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\Library\MicoCloudService\MicoMQTTClient\MQTTPacket\src\MQTTSubscribeServer.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\Library\MicoCloudService\MicoMQTTClient\MQTTPacket\src\MQTTUnsubscribeClient.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\Library\MicoCloudService\MicoMQTTClient\MQTTPacket\src\MQTTUnsubscribeServer.c</name>
            </file>
          </group>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\Library\MicoCloudService\MicoMQTTClient\MicoMQTTClient.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Library\MicoCloudService\MicoMQTTClient\MicoMQTTClient.h</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\Library\MicoCloudService\MicoCloudService.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Library\MicoCloudService\MicoCloudService.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Library\MicoCloudService\MicoCloudServiceDef.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Library\MicoCloudService\MicoCloudServiceVersion.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>MICO</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICODefine.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICONotificationCenter.c</name>
    </file>
  </group>
  <group>
    <name>Support</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\HTTPUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\SocketUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\StringUtils.c</name>
    </file>
  </group>
</project>


